# IAR project USB_VCOM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F103CBT MindMotion MM32F103CBT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_IAR; F103_N_VERSION
  ICCARM.CCIncludePath2: ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\uart; ..\..\..\..\..\Device\MM32F103\HAL_lib\inc; ..\..\..\..\..\Device\MM32F103\Include; ..\..\..\..\..\Device\CMSIS\IAR_CORE; ..\bsp; ..\bsp\usblib; ..\HARDWARE\UART
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MBOUT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../bsp/test/: usbapp.c
  group HALlib
    ../../../../../Device/MM32F103/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group HARDWARE
    ../HARDWARE/UART/: uart_usb.c
  group README
    ../: README.TXT
  group STARTUP
    ../../../../../Device/MM32F103/Source/IAR_StartAsm/: startup_MM32F103.s
    ../../../../../Device/MM32F103/Source/: system_MM32F103.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group usbdriver
    ../bsp/usblib/: ctrlitem.c ctrlusb.c usbprop.c usbreg.c
  group USER
    ../bsp/test/: main.c

# IAR project EVBoard_SPI_FLASH.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F103CBT MindMotion MM32F103CBT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR; F103_N_VERSION
  ICCARM.CCIncludePath2: ..\HARDWARE\LED; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\uart; ..\..\..\..\..\Device\MM32F103\Include; ..\HARDWARE\LCDC; ..\HARDWARE\LED; ..\HARDWARE\SPI; ..\HARDWARE\KEY; ..\..\..\..\..\Device\CMSIS\IAR_CORE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ManleyDK103.srec
  ILINK.IlinkOutputFile: EVBOUT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCDC/: lcdc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
  group STARTUP
    ../../../../../Device/MM32F103/Source/IAR_StartAsm/: startup_MM32F103.s
    ../../../../../Device/MM32F103/Source/: system_MM32F103.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group USER
    ../USER/: main.c

# Keil uVision project FullDuplex_SoftNSS.uvprojx, settings and files
target projectgroup (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32F103CBT MindMotion
  pack: MindMotion.MM32F103_DFP.1.4.3
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT +hex
  c flags: Optim=1 OneElfS=1
  c define: F103_N_VERSION
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\HARDWARE\LED;..\HARDWARE\KEY;..\..\..\..\..\Device\MM32F103\Include;..\HARDWARE\SPI;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  asm define: F103_N_VERSION
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32F103/Source/: system_MM32F103.c
    ../../../../../Device/MM32F103/Source/KEIL_StartAsm/: startup_MM32F103.s
  group USER
    ../USER/: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
  group README
    ../: README.TXT

# Keil uVision project USB_Keyboard.uvprojx, settings and files
target projectgroup (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32F103CBT MindMotion
  pack: MindMotion.MM32F103_DFP.1.4.3
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MBOUT
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: F103_N_VERSION
  c include: ..\bsp;..\bsp\test;..\bsp\usblib;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\..\..\..\..\Device\MM32F103\Include;..\HARDWARE\KEY;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  asm define: F103_N_VERSION
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32F103/Source/: system_MM32F103.c
    ../../../../../Device/MM32F103/Source/KEIL_StartAsm/: startup_MM32F103.s
  group BSP
    ../bsp/test/: main.c usbapp.c
    ../HARDWARE/KEY/: key.c
  group USBAPP
    ../bsp/usblib/: bulkitem.c bulkusb.c ctrlitem.c ctrlusb.c usbreg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group README
    ../: README.TXT

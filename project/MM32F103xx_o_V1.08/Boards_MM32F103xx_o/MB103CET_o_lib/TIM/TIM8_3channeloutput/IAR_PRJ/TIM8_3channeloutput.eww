<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TIM8_3channeloutput.ewp</path>
  </project>
  <batchBuild/>
</workspace>



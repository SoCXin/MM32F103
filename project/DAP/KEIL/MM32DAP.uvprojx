# Keil uVision project MM32DAP.uvprojx, settings and files
target MM32DAP_V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F103C8T MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32DAP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER MM32F10X_MD BOARD_V2 F103_N_VERSION
  c include: ..\DAP;..\MM32x103\HAL_lib\inc;..\MM32x103\Include;..\USBD;..\USBStack\inc;..\USER;..\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../MM32x103/Source/: system_MM32F103.c
    ../MM32x103/Source/KEIL_StartAsm/: startup_MM32F103.s
  group HAL_lib
    ../MM32x103/HAL_lib/src/: HAL_uart.c HAL_rcc.c HAL_misc.c HAL_flash.c HAL_gpio.c
  group USB_lib
    ../USBStack/: USB_CM3.lib
  group USBD
    ../USBD/: usb_config.c usbd_MM32F103.c usbd_user_cdc_acm.c usbd_user_hid.c
  group Userapp
    ../USER/: CMSIS-DAP.c UserApp.c
  group README
    ../: README.txt

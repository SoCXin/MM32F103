<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EVBoard_FLASH_simulate_EEPROM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


